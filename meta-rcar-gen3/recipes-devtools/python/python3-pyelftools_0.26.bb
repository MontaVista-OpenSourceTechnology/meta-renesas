inherit setuptools3
require python-pyelftools.inc

COMPATIBLE_MACHINE = "rcar-gen3"
