# Due to compile error with Kernel 5.10.41, strace will be temporary
# removed
RDEPENDS:${PN}:remove_rcar-gen5 = "${STRACE}"
