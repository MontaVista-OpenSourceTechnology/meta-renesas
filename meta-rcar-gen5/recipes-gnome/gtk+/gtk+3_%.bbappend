PACKAGECONFIG:remove:rcar-gen5 = "wayland"
