DEPENDS:append:rcar-gen5 = " wayland-kms libgbm"
