# Add support nativesdk
BBCLASSEXTEND:append:rcar-gen5 = " nativesdk"
